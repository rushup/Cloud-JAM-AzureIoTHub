# IAR project Project.ewp, settings and files
configuration STM32F401RE_Nucleo_IKS01A2 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE; USE_STM32F4XX_NUCLEO; USART_PRINT_MSG; EINVAL=-1; ENOMEM=EINVAL; USE_GENERICACCESSKEY_IOTHUB=0; REFCOUNT_ATOMIC_DONTCARE=1; DONT_USE_UPLOADTOBLOB=1; NO_LOGGING=1; __IKS01A2; __NUCLEO_BUILD
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo; ..\..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA\Utils; ..\..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA\Inc; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDW01M1; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-NFC01A1; ..\..\..\..\..\..\Middlewares\Third_Parties\FreeRTOS\Source\include; ..\..\..\..\..\..\Middlewares\Third_Parties\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\..\Middlewares\Third_Parties\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components\lps25hb; ..\..\..\..\..\..\Drivers\BSP\Components\hts221; ..\..\..\..\..\..\Drivers\BSP\Components\lis3mdl; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds0; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds3; ..\..\..\..\..\..\Drivers\BSP\Components\M24SR; ..\..\..\..\..\..\Middlewares\ST\lib_NDEF\inc; ..\..\..\..\..\..\Middlewares\Third_Parties\AzureIOT\azure-c-shared-utility\adapters\inc; ..\..\..\..\..\..\Middlewares\Third_Parties\AzureIOT\iothub_client\inc; ..\..\..\..\..\..\Middlewares\Third_Parties\AzureIOT\serializer\inc; ..\..\..\..\..\..\Middlewares\Third_Parties\AzureIOT\azure-c-shared-utility\inc; ..\..\..\..\..\..\Middlewares\Third_Parties\AzureIOT\azure-c-shared-utility\adapters\httpapi_STM32Cube\inc; ..\..\..\..\..\..\Middlewares\Third_Parties\AzureIOT\azure-c-shared-utility\adapters\agenttime_STM32Cube\inc; ..\..\..\..\..\..\Middlewares\Third_Parties\AzureIOT\iothub_client\sample; ..\..\..\..\..\..\Drivers\BSP\Components\lps22hb; ..\..\..\..\..\..\Drivers\BSP\Components\lsm303agr; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsl; ..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A2; ..\..\..\..\..\..\Drivers\BSP\Components\iis2dh
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Inc
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F401RE_Nucleo_IKS01A1 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE; USE_STM32F4XX_NUCLEO; USART_PRINT_MSG; EINVAL=-1; ENOMEM=EINVAL; USE_GENERICACCESSKEY_IOTHUB=0; REFCOUNT_ATOMIC_DONTCARE=1; DONT_USE_UPLOADTOBLOB=1; NO_LOGGING=1; __NUCLEO_BUILD
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo; ..\..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA\Utils; ..\..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA\Inc; ..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A1; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDW01M1; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-NFC01A1; ..\..\..\..\..\..\Middlewares\Third_Parties\FreeRTOS\Source\include; ..\..\..\..\..\..\Middlewares\Third_Parties\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\..\Middlewares\Third_Parties\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components\lps25hb; ..\..\..\..\..\..\Drivers\BSP\Components\hts221; ..\..\..\..\..\..\Drivers\BSP\Components\lis3mdl; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds0; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds3; ..\..\..\..\..\..\Drivers\BSP\Components\M24SR; ..\..\..\..\..\..\Middlewares\ST\lib_NDEF\inc; ..\..\..\..\..\..\Middlewares\Third_Parties\AzureIOT\azure-c-shared-utility\adapters\inc; ..\..\..\..\..\..\Middlewares\Third_Parties\AzureIOT\iothub_client\inc; ..\..\..\..\..\..\Middlewares\Third_Parties\AzureIOT\serializer\inc; ..\..\..\..\..\..\Middlewares\Third_Parties\AzureIOT\azure-c-shared-utility\inc; ..\..\..\..\..\..\Middlewares\Third_Parties\AzureIOT\azure-c-shared-utility\adapters\httpapi_STM32Cube\inc; ..\..\..\..\..\..\Middlewares\Third_Parties\AzureIOT\azure-c-shared-utility\adapters\agenttime_STM32Cube\inc; ..\..\..\..\..\..\Middlewares\Third_Parties\AzureIOT\iothub_client\sample; ..\..\..\..\..\..\Drivers\BSP\Components\lps22hb; ..\..\..\..\..\..\Drivers\BSP\Components\iis2dh; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsl; ..\..\..\..\..\..\Drivers\BSP\Components\lsm303agr
  ICCARM.CCOptLevel: 2
  group AzureSDK/EWARM
    ./: startup_stm32f401xe.s
  group AzureSDK/User
    ../../Src/: console.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Drivers/BSP/Components/IKS01
    ../../../../../../Drivers/BSP/Components/hts221/: HTS221_Driver.c HTS221_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/iis2dh/: IIS2DH_Driver.c IIS2DH_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lis3mdl/: LIS3MDL_MAG_driver.c LIS3MDL_MAG_driver_HL.c
    ../../../../../../Drivers/BSP/Components/lps22hb/: LPS22HB_Driver.c LPS22HB_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lps25hb/: LPS25HB_Driver.c LPS25HB_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm303agr/: LSM303AGR_ACC_driver.c LSM303AGR_ACC_driver_HL.c LSM303AGR_MAG_driver.c LSM303AGR_MAG_driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm6ds0/: LSM6DS0_ACC_GYRO_driver.c LSM6DS0_ACC_GYRO_driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm6ds3/: LSM6DS3_ACC_GYRO_driver.c LSM6DS3_ACC_GYRO_driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm6dsl/: LSM6DSL_ACC_GYRO_driver.c LSM6DSL_ACC_GYRO_driver_HL.c
  group Drivers/BSP/Components/NFC01A1
    ../../../../../../Drivers/BSP/Components/M24SR/: lib_M24SR.c m24sr.c
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_I2C.c stm32f4xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IDW01M1
    ../../../../../../Drivers/BSP/X-NUCLEO-IDW01M1/: stm32_spwf_wifi.c
  group Drivers/BSP/X-NUCLEO-IKS01A1
    ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1/: x_nucleo_iks01a1.c x_nucleo_iks01a1_accelero.c x_nucleo_iks01a1_gyro.c x_nucleo_iks01a1_humidity.c x_nucleo_iks01a1_magneto.c x_nucleo_iks01a1_pressure.c x_nucleo_iks01a1_temperature.c
  group Drivers/BSP/X-NUCLEO-IKS01A2
    ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A2/: x_nucleo_iks01a2.c x_nucleo_iks01a2_accelero.c x_nucleo_iks01a2_gyro.c x_nucleo_iks01a2_humidity.c x_nucleo_iks01a2_magneto.c x_nucleo_iks01a2_pressure.c x_nucleo_iks01a2_temperature.c
  group Drivers/BSP/X-NUCLEO-NFC01A1
    ../../../../../../Drivers/BSP/X-NUCLEO-NFC01A1/: drv_I2C_M24SR.c
  group Drivers/CMSIS
    ../../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_msp_template.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c
  group Middlewares/AzureIOT/azure-c-shared-utility/adapter
    ../../../../../../Middlewares/Third_Parties/AzureIOT/azure-c-shared-utility/adapters/: agenttime_STM32Cube.c httpapi_STM32Cube.c lock_STM32Cube.c platform_STM32Cube.c threadapi_STM32Cube.c tickcounter_STM32Cube.c
  group Middlewares/AzureIOT/azure-c-shared-utility/adapter/agenttime_STM32Cube
    ../../../../../../Middlewares/Third_Parties/AzureIOT/azure-c-shared-utility/adapters/agenttime_STM32Cube/: SynchronizationAgent.c timingSystem.c timingSystemNucleoF4.c
  group Middlewares/AzureIOT/azure-c-shared-utility/adapter/httpapi_STM32Cube
    ../../../../../../Middlewares/Third_Parties/AzureIOT/azure-c-shared-utility/adapters/httpapi_STM32Cube/: InternetAdapter.c InternetInterface.c SocketMapping.c SocketOS.c
  group Middlewares/AzureIOT/azure-c-shared-utility/src
    ../../../../../../Middlewares/Third_Parties/AzureIOT/azure-c-shared-utility/src/: base64.c buffer.c consolelogger.c crt_abstractions.c doublylinkedlist.c gb_stdio.c gb_time.c gballoc.c hmac.c hmacsha256.c httpapiex.c httpapiexsas.c httpheaders.c list.c map.c sastoken.c sha1.c sha224.c sha384-512.c string_tokenizer.c strings.c urlencode.c usha.c vector.c xio.c xlogging.c
  group Middlewares/AzureIOT/iothub_client/sample
    ../../../../../../Middlewares/Third_Parties/AzureIOT/iothub_client/sample/: iothub_client_sample_http.c
  group Middlewares/AzureIOT/iothub_client/src
    ../../../../../../Middlewares/Third_Parties/AzureIOT/iothub_client/src/: iothub_client.c iothub_client_ll.c iothub_message.c iothubtransport.c iothubtransporthttp.c version.c
  group Middlewares/AzureIOT/serializer/src
    ../../../../../../Middlewares/Third_Parties/AzureIOT/serializer/src/: agenttypesystem.c codefirst.c commanddecoder.c datamarshaller.c datapublisher.c dataserializer.c iotdevice.c jsondecoder.c jsonencoder.c multitree.c schema.c schemalib.c schemaserializer.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Parties/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../../../Middlewares/Third_Parties/FreeRTOS/Source/: croutine.c event_groups.c list_rt.c queue.c tasks.c timers.c
    ../../../../../../Middlewares/Third_Parties/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Parties/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/LibNDEF
    ../../../../../../Middlewares/ST/lib_NDEF/src/: lib_NDEF.c lib_NDEF_AAR.c lib_NDEF_Email.c lib_NDEF_Geo.c lib_NDEF_MyApp.c lib_NDEF_SMS.c lib_NDEF_URI.c lib_NDEF_Vcard.c lib_NDEF_Wifi.c lib_TagType4.c
  group Middlewares/STM32_SPWF01SA
    ../../../../../../Middlewares/ST/STM32_SPWF01SA/: wifi_interface.c wifi_module.c
  group Middlewares/STM32_SPWF01SA/Utils
    ../../../../../../Middlewares/ST/STM32_SPWF01SA/Utils/: event_buffer.c ring_buffer.c wifi_globals.c
